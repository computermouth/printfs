## Config.in
```kconfig
config BR2_PACKAGE_PRINTFS
	bool "printfs"
	help
	  Small program to grab raw data from gadget print device.
```
